# Keil uVision project STM32F745ZG_RTOS_001.uvprojx, settings and files
target STM32F745ZG_RTOS_001 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F745ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F745ZG_RTOS_001
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Sources
    ./: main.c MCU_Config.c Thread.c SevenSegmentDisplay_Driver.c button_relay_driver.c
  group Headers
    ./: MCU_Config.h SevenSegmentDisplay_Driver.h button_relay_driver.h
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:ADC 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:ETH 1.3.0, Device:STM32Cube HAL:EXTI 1.3.0, Device:STM32Cube HAL:Flash 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:TIM 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:STM32Cube HAL:USART 1.3.0, Device:Startup 1.2.5
